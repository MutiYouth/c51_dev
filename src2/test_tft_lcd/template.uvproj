# Keil uVision project template.uvproj, settings and files
target Target 1 tft basic (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: target1_tft_basic +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\Public;.\GUI;.\APP\tftlcd;.\APP\touch
  group User
    ./User/: main.c
  group Public
    ./Public/: public.c uart.c public.h uart.h
  group APP
    ./APP/tftlcd/: tftlcd.c font.h picture.h tftlcd.h
    ./APP/touch/: touch.c touch.h
  group GUI
    ./GUI/: gui.c gui.h
