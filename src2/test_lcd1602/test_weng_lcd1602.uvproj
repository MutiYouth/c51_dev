# Keil uVision project test_weng_lcd1602.uvproj, settings and files
target Target 16 lcd1602 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: target16_lcd6102 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 16 lcd1602
    ./src/: lcd.c lcd.h main16_lcd1602.c
