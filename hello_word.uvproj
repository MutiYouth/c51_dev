# Keil uVision project hello_word.uvproj, settings and files
target Target 1 lights (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: target_lights +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1 lights
    ./src/: main.c
  group Source Group 2 beep
    ./src/: main_2_beep.c
  group Source Group 3 8-bit-display
    ./src/: main_3_8_bit_display.c
  group Source Group 4 switch
    ./src/: main_4_switch.c
  group Source Group 5 matrix switch
    ./src/: main_5_matrix_switch.c
  group Source Group 6 led_line
    ./src/: main_6.c
  group Source Group 7 electric
    ./src/: main_7_electric.c
  group Source Group 8 interrupt
    ./src/: main_8_interrupt.c
  group Source Group 9 timer
    ./src/: main_9_timer.c
  group Source Group 10 eprom iic
    ./src/10/: i2c.c i2c.h main_10.c
  group Source Group 11 temperature
    ./src/11_temperature/: main_11.c temp.c temp.h
  group Source Group 12 clock
    ./src/12_clock/: ds1302.c main12_clock.c ds1302.h
  group Source Group 13 Infrared
    ./src/13_Infrared/: main13_Infrared.c
  group Source Group 14 adc
    ./src/14_AD模数转换/: main_14_ad.c XPT2046.c XPT2046.h
  group Source Group 15 dac
    ./src/15_DA数模转换/: main15_da.c
  group Source Group 16 lcd1602
    ./src/16_LCD1602/: lcd.c lcd.h main16_lcd1602.c
target Target 2 beep (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: target2_beep +hex
  c flags: Optimize=8 SizeSpeed=1
target Target 3 8-bit-display (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: target3_8_bit_display +hex
  c flags: Optimize=8 SizeSpeed=1
target Target 4 switch (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: target4_switch +hex
  c flags: Optimize=8 SizeSpeed=1
target Target 5 matrix switch (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: target5_matrix_switch +hex
  c flags: Optimize=8 SizeSpeed=1
target Target 6 led_line (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: target6_led_line +hex
  c flags: Optimize=8 SizeSpeed=1
target Target 7 electric (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: target7_electric +hex
  c flags: Optimize=8 SizeSpeed=1
target Target 8 interrupt (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: target8_interrupt +hex
  c flags: Optimize=8 SizeSpeed=1
target Target 9 timer (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: target9_timer +hex
  c flags: Optimize=8 SizeSpeed=1
target Target 10 eprom iic (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: target10_eprom_iic +hex
  c flags: Optimize=8 SizeSpeed=1
target Target 11  temperature (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: target11_ temperature +hex
  c flags: Optimize=8 SizeSpeed=1
target Target 12 clock (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: target12_clock +hex
  c flags: Optimize=8 SizeSpeed=1
target Target 13 Infrared (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: target13_Infrared +hex
  c flags: Optimize=8 SizeSpeed=1
target Target 14 adc (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: target14_adc +hex
  c flags: Optimize=8 SizeSpeed=1
target Target 15 dac (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: target16_lcd1602 +hex
  c flags: Optimize=8 SizeSpeed=1
target Target 16 lcd1602 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: target16_lcd1602 +hex
  c flags: Optimize=8 SizeSpeed=1
target Target 17 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: target9_timer +hex
  c flags: Optimize=8 SizeSpeed=1
target Target 18 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: target9_timer +hex
  c flags: Optimize=8 SizeSpeed=1
